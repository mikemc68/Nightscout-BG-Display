/*
  Nightscout BG display
  ESP32-S3 + 3.5" 480x320 AXS15231B (Guition JC4832W535 / JC3248W535), landscape.

  Libraries (Library Manager):
    - GFX Library for Arduino  (moononournation) 1.5.0+
    - ArduinoJson              (Benoit Blanchon) 7.x
  Board: ESP32S3 Dev Module, Flash 16MB, a 16M partition scheme,
         PSRAM: OPI PSRAM, USB CDC On Boot: Enabled

  Settings (Wi-Fi, Nightscout address, sensor) are in config.h.
*/

#define ARDUINOJSON_USE_LONG_LONG 1
#include <WiFi.h>
#include <WiFiClientSecure.h>
#include <HTTPClient.h>
#include <ArduinoJson.h>
#include <Arduino_GFX_Library.h>
#include <time.h>
#include <math.h>
#include "config.h"

// Defaults for any setting missing from config.h (e.g. an older config.h).
// To change one, add the same #define to config.h.
#ifndef WIFI_SSID_2
#define WIFI_SSID_2           ""
#define WIFI_PASSWORD_2       ""
#endif
#ifndef WIFI_SSID_3
#define WIFI_SSID_3           ""
#define WIFI_PASSWORD_3       ""
#endif
#ifndef FETCH_INTERVAL_S
#define FETCH_INTERVAL_S      60
#endif
#ifndef STALE_MINUTES
#define STALE_MINUTES         15
#endif
#ifndef GRAPH_HOURS_START
#define GRAPH_HOURS_START     3
#endif
#ifndef FLASH_ON_SINGLE_DOWN
#define FLASH_ON_SINGLE_DOWN  1
#endif
#ifndef ALARM_ENABLED
#define ALARM_ENABLED         1
#endif
#ifndef ALARM_VOLUME
#define ALARM_VOLUME          60
#endif
#ifndef ALARM_REPEAT_S
#define ALARM_REPEAT_S        20
#endif
#ifndef SNOOZE_MINUTES
#define SNOOZE_MINUTES        30
#endif
#ifndef STARTUP_BEEP
#define STARTUP_BEEP          1
#endif
#ifndef NIGHT_START_HOUR
#define NIGHT_START_HOUR      22
#endif
#ifndef NIGHT_END_HOUR
#define NIGHT_END_HOUR        7
#endif
#ifndef DAY_BRIGHTNESS
#define DAY_BRIGHTNESS        255
#endif
#ifndef NIGHT_BRIGHTNESS
#define NIGHT_BRIGHTNESS      25
#endif
#ifndef TEST_FORCE_LOW
#define TEST_FORCE_LOW        0
#endif
#include "fonts.h"   // smooth Noto Sans fonts + trend arrows (generated by tools/make_fonts.ps1)
#include "touch.h"   // tap detection
#include "beeper.h"  // speaker

// ======================================================================
//  Display
// ======================================================================
#define TFT_CS   45
#define TFT_SCK  47
#define TFT_D0   21
#define TFT_D1   48
#define TFT_D2   40
#define TFT_D3   39
#define TFT_BL    1

Arduino_DataBus *bus = new Arduino_ESP32QSPI(TFT_CS, TFT_SCK, TFT_D0, TFT_D1, TFT_D2, TFT_D3);
Arduino_GFX *panel = new Arduino_AXS15231B(bus, GFX_NOT_DEFINED, 0, false, 320, 480);
// Last argument = rotation. 1 = landscape; use 3 if the picture is upside down.
Arduino_Canvas *gfx = new Arduino_Canvas(320, 480, panel, 0, 0, 1);

#define COL(r, g, b) ((uint16_t)((((r) & 0xF8) << 8) | (((g) & 0xFC) << 3) | ((b) >> 3)))
const uint16_t C_BLACK = 0x0000;
const uint16_t C_OK    = COL(0x5D, 0xCA, 0xA5);  // in range
const uint16_t C_WARN  = COL(0xEF, 0x9F, 0x27);  // out of target
const uint16_t C_URG   = COL(0xF2, 0x5C, 0x5C);  // urgent
const uint16_t C_GREY  = COL(0x60, 0x60, 0x60);  // stale
const uint16_t C_DIM   = COL(0x8A, 0x8A, 0x8A);  // top bar
const uint16_t C_SUB   = COL(0xBD, 0xBD, 0xBD);
const uint16_t C_BAND  = COL(0x06, 0x34, 0x28);  // target band in graph
const uint16_t C_DASH  = COL(0x80, 0x55, 0x10);
const uint16_t C_AXIS  = COL(0x70, 0x70, 0x70);

// ======================================================================
//  Data
// ======================================================================
const float MGDL_PER_MMOL = 18.0f;

// Thresholds in mmol/L. Defaults = Nightscout defaults; replaced by your site's settings.
float thUrgLow = 55 / MGDL_PER_MMOL, thLow = 80 / MGDL_PER_MMOL;
float thHigh = 180 / MGDL_PER_MMOL, thUrgHigh = 260 / MGDL_PER_MMOL;

struct Reading { time_t t; float mmol; };
const int MAX_READINGS = 800;          // Libre2 uploads every minute -> ~13 hours
const int INC_COUNT = 60;              // readings asked for in a minute-by-minute update
Reading readings[MAX_READINGS];        // newest first
Reading fetched[MAX_READINGS];         // download buffer
int nReadings = 0;
char trend[24] = "";
bool haveData = false;
String lastError;

// Wi-Fi networks from config.h (empty names are skipped)
const char *WIFI_NAMES[3] = {WIFI_SSID, WIFI_SSID_2, WIFI_SSID_3};
const char *WIFI_PASSES[3] = {WIFI_PASSWORD, WIFI_PASSWORD_2, WIFI_PASSWORD_3};
uint32_t lostSinceMs = 0;              // when the connection dropped (0 = connected / never tried)
bool wasConnected = false;

uint32_t lastFetchMs = 0, nextStatusMs = 0, lastDrawMs = 0, lastFullFetchMs = 0;
bool fetchedOnce = false, ntpStarted = false, needFullFetch = true;

// Graph range (tap to cycle)
const int GRAPH_RANGES[] = {3, 6, 12};
int graphHours = GRAPH_HOURS_START;

// Alarm / flashing / backlight state
uint32_t snoozeUntilMs = 0;            // 0 = not snoozed
uint32_t lastAlarmMs = 0;              // 0 = alarm not sounding
bool lastTouch = false;
int lastFlashPhase = -1;
int backlightLevel = -1;

// ======================================================================
//  Helpers
// ======================================================================
time_t nowUtc() {
  time_t t = time(nullptr);
  return t > 1700000000 ? t : 0;   // 0 = clock not set yet
}

uint16_t colorFor(float v) {
  if (v <= thUrgLow || v >= thUrgHigh) return C_URG;
  if (v < thLow || v > thHigh) return C_WARN;
  return C_OK;
}

String withToken(String url) {
  if (strlen(NS_TOKEN) > 0) url += String(url.indexOf('?') < 0 ? "?" : "&") + "token=" + NS_TOKEN;
  return url;
}

// ======================================================================
//  Smooth text (anti-aliased glyphs from fonts.h, blended over black)
// ======================================================================
void makeLut(uint16_t c, uint16_t *lut) {
  uint16_t r = (c >> 11) & 0x1F, g = (c >> 5) & 0x3F, b = c & 0x1F;
  for (int a = 0; a < 16; a++)
    lut[a] = ((r * a / 15) << 11) | ((g * a / 15) << 5) | (b * a / 15);
}

void aaGlyph(const AAFont &f, const AAGlyph &g, int x, int y, const uint16_t *lut) {
  const uint8_t *bm = f.bitmap + g.offset;
  int n = g.w * g.h;
  for (int i = 0; i < n; i++) {
    uint8_t a = (i & 1) ? (bm[i >> 1] & 0x0F) : (bm[i >> 1] >> 4);
    if (a) gfx->drawPixel(x + g.xOff + i % g.w, y + g.yOff + i / g.w, lut[a]);
  }
}

int aaWidth(const AAFont &f, const char *s, int tracking) {
  int w = 0;
  for (const char *p = s; *p; p++) {
    uint8_t ch = *p;
    if (ch < f.first || ch > f.last) continue;
    w += f.glyphs[ch - f.first].advance + (p[1] ? tracking : 0);
  }
  return w;
}

// x = left edge, baseline = text baseline
void aaText(const AAFont &f, int x, int baseline, const char *s, uint16_t c, int tracking) {
  uint16_t lut[16];
  makeLut(c, lut);
  for (const char *p = s; *p; p++) {
    uint8_t ch = *p;
    if (ch < f.first || ch > f.last) continue;
    const AAGlyph &g = f.glyphs[ch - f.first];
    aaGlyph(f, g, x, baseline, lut);
    x += g.advance + tracking;
  }
}

void aaTextCentered(const AAFont &f, int cx, int baseline, const char *s, uint16_t c) {
  aaText(f, cx - aaWidth(f, s, 0) / 2, baseline, s, c, 0);
}

// Arrow glyphs are stored relative to their centre.
void aaIcon(const AAFont &f, char ch, int cx, int cy, uint16_t c) {
  uint16_t lut[16];
  makeLut(c, lut);
  aaGlyph(f, f.glyphs[(uint8_t)ch - f.first], cx, cy, lut);
}

// ======================================================================
//  Nightscout
// ======================================================================
bool httpGetJson(const String &url, JsonDocument &doc, JsonDocument &filter) {
  WiFiClientSecure client;
  client.setInsecure();              // read-only public data; skip certificate check
  HTTPClient http;
  http.useHTTP10(true);              // no chunked encoding -> can stream straight into ArduinoJson
  http.setConnectTimeout(30000);     // free Render servers can take a while to wake up
  http.setTimeout(30000);
  if (!http.begin(client, url)) { lastError = "Bad URL"; return false; }
  int code = http.GET();
  if (code != HTTP_CODE_OK) {
    lastError = "Nightscout HTTP " + String(code);
    http.end();
    return false;
  }

  // Download the whole reply into PSRAM first, then decode it. Decoding straight
  // from the encrypted connection can stall and cut large replies short.
  static const size_t BUF_SIZE = 1024 * 1024;     // 13 hours of readings is ~320 KB
  static char *buf = nullptr;
  if (!buf) buf = (char *)ps_malloc(BUF_SIZE);
  if (!buf) { lastError = "No PSRAM for download"; http.end(); return false; }

  WiFiClient *s = http.getStreamPtr();
  size_t len = 0;
  uint32_t lastData = millis();
  while (len < BUF_SIZE - 1) {
    int avail = s->available();
    if (avail > 0) {
      size_t want = (size_t)avail;
      if (want > BUF_SIZE - 1 - len) want = BUF_SIZE - 1 - len;
      int n = s->read((uint8_t *)buf + len, want);
      if (n > 0) { len += n; lastData = millis(); }
    } else if (!s->connected()) {
      break;                                       // server finished sending
    } else if (millis() - lastData > 20000) {
      lastError = "Download stalled at " + String((unsigned)len) + " bytes";
      http.end();
      return false;
    } else {
      delay(2);
    }
  }
  http.end();
  Serial.printf("Downloaded %u bytes\n", (unsigned)len);
  if (len >= BUF_SIZE - 1) { lastError = "Reply too big"; return false; }

  DeserializationError err = deserializeJson(doc, (const char *)buf, len, DeserializationOption::Filter(filter));
  if (err) {
    lastError = String("Bad data: ") + err.c_str() + " (" + String((unsigned)len) + " bytes)";
    return false;
  }
  return true;
}

bool fetchStatus() {
  JsonDocument filter;
  filter["settings"]["thresholds"] = true;
  JsonDocument doc;
  if (!httpGetJson(withToken(String(NS_URL) + "/api/v1/status.json"), doc, filter)) return false;
  JsonObject th = doc["settings"]["thresholds"];
  if (th.isNull()) return false;
  thUrgLow  = (th["bgLow"]          | 55)  / MGDL_PER_MMOL;
  thLow     = (th["bgTargetBottom"] | 80)  / MGDL_PER_MMOL;
  thHigh    = (th["bgTargetTop"]    | 180) / MGDL_PER_MMOL;
  thUrgHigh = (th["bgHigh"]         | 260) / MGDL_PER_MMOL;
  Serial.printf("Thresholds (mmol/L): urgent low %.1f, low %.1f, high %.1f, urgent high %.1f\n",
                thUrgLow, thLow, thHigh, thUrgHigh);
  return true;
}

// Downloads readings (newest first) into fetched[]. Returns how many, or -1 on error.
int downloadReadings(const String &query, char *trendOut, size_t trendLen) {
  JsonDocument filter;
  filter[0]["date"] = true;
  filter[0]["sgv"] = true;
  filter[0]["direction"] = true;
  JsonDocument doc;
  String url = String(NS_URL) + "/api/v1/entries/sgv.json?find[device]=" + NS_DEVICE + query;
  if (!httpGetJson(withToken(url), doc, filter)) return -1;

  int n = 0;
  for (JsonObject e : doc.as<JsonArray>()) {
    if (n >= MAX_READINGS) break;
    int64_t ms = e["date"].as<int64_t>();
    float sgv = e["sgv"].as<float>();
    if (ms <= 0 || sgv <= 0) continue;
    fetched[n].t = (time_t)(ms / 1000);
    fetched[n].mmol = sgv / MGDL_PER_MMOL;
    if (n == 0) strlcpy(trendOut, e["direction"] | "", trendLen);
    n++;
  }
  return n;
}

// Full download (~13 hours): at start-up, hourly, and after a long gap.
// Otherwise only readings newer than the latest one we have, added to the front.
bool fetchEntries() {
  char newTrend[24] = "";
  if (needFullFetch || !haveData) {
    int n = downloadReadings(String("&count=") + MAX_READINGS, newTrend, sizeof newTrend);
    if (n < 0) return false;
    if (n == 0) { lastError = "No readings for " NS_DEVICE; return false; }
    memcpy(readings, fetched, n * sizeof(Reading));
    nReadings = n;
    needFullFetch = false;
    lastFullFetchMs = millis();
    Serial.printf("Full download: %d readings\n", n);
  } else {
    char q[80];
    snprintf(q, sizeof q, "&count=%d&find[date][$gt]=%lld", INC_COUNT, (long long)readings[0].t * 1000LL + 999LL);
    int n = downloadReadings(q, newTrend, sizeof newTrend);
    if (n < 0) return false;
    if (n >= INC_COUNT) {               // missed too much: get everything next time
      needFullFetch = true;
      return fetchEntries();
    }
    int k = 0;                          // how many are actually newer
    while (k < n && fetched[k].t > readings[0].t) k++;
    if (k > 0) {
      int keep = min(nReadings, MAX_READINGS - k);
      memmove(readings + k, readings, keep * sizeof(Reading));
      memcpy(readings, fetched, k * sizeof(Reading));
      nReadings = keep + k;
    }
    Serial.printf("Update: %d new readings\n", k);
    if (k == 0) newTrend[0] = 0;        // keep the trend we already have
  }
  if (newTrend[0]) strlcpy(trend, newTrend, sizeof trend);
  if (TEST_FORCE_LOW) {                 // see config.h
    readings[0].mmol = 2.8f;
    strlcpy(trend, "DoubleDown", sizeof trend);
  }
  haveData = true;
  lastError = "";
  Serial.printf("Latest %.1f %s\n", readings[0].mmol, trend);
  return true;
}

// Change over ~5 minutes, like Nightscout shows.
bool getDelta(float &d) {
  if (nReadings < 2) return false;
  time_t target = readings[0].t - 300;
  int best = -1; long bestDiff = 1000000;
  for (int i = 1; i < nReadings; i++) {
    long diff = labs((long)(readings[i].t - target));
    if (diff < bestDiff) { bestDiff = diff; best = i; }
  }
  if (best < 0 || bestDiff > 120) return false;
  d = roundf(readings[0].mmol * 10) / 10 - roundf(readings[best].mmol * 10) / 10;
  if (fabsf(d) < 0.05f) d = 0.0f;
  return true;
}

// ======================================================================
//  Alerts, flashing, night mode
// ======================================================================
// Minutes since the latest reading; -1 if the clock isn't set yet.
long readingAgeMin() {
  time_t now = nowUtc();
  if (!haveData || !now) return -1;
  long a = (long)(now - readings[0].t) / 60;
  return a < 0 ? 0 : a;
}

bool dataFresh() { return haveData && readingAgeMin() < STALE_MINUTES; }

bool fallingFast() {
  if (!strcmp(trend, "DoubleDown")) return true;
  return FLASH_ON_SINGLE_DOWN && !strcmp(trend, "SingleDown");
}

bool shouldFlash() { return dataFresh() && (readings[0].mmol < thLow || fallingFast()); }

bool lowAlarm() { return ALARM_ENABLED && dataFresh() && readings[0].mmol <= thUrgLow; }

bool snoozed() { return snoozeUntilMs != 0 && (int32_t)(millis() - snoozeUntilMs) < 0; }

int snoozeMinutesLeft() { return snoozed() ? (int)((snoozeUntilMs - millis()) / 60000) + 1 : 0; }

bool isNight() {
  time_t now = nowUtc();
  if (!now) return false;
  struct tm tm;
  localtime_r(&now, &tm);
  int h = tm.tm_hour;
  if (NIGHT_START_HOUR > NIGHT_END_HOUR) return h >= NIGHT_START_HOUR || h < NIGHT_END_HOUR;
  return h >= NIGHT_START_HOUR && h < NIGHT_END_HOUR;
}

void updateBacklight() {
  int level = (lowAlarm() && !snoozed()) ? 255 : (isNight() ? NIGHT_BRIGHTNESS : DAY_BRIGHTNESS);
  if (level != backlightLevel) {
    ledcWrite(TFT_BL, level);
    backlightLevel = level;
  }
}

// ======================================================================
//  Trend arrow
// ======================================================================
// Arrow glyphs: '0' Flat, '1' FortyFiveUp, '2' SingleUp, '3' FortyFiveDown, '4' SingleDown
const int DOUBLE_GAP = 62;   // distance between the two arrows of DoubleUp / DoubleDown

// Which arrow glyph to use; double = draw two small ones. Returns 0 if no arrow.
char trendGlyph(const char *d, bool &dbl) {
  dbl = false;
  if (!strcmp(d, "Flat")) return '0';
  if (!strcmp(d, "FortyFiveUp")) return '1';
  if (!strcmp(d, "SingleUp")) return '2';
  if (!strcmp(d, "FortyFiveDown")) return '3';
  if (!strcmp(d, "SingleDown")) return '4';
  dbl = true;
  if (!strcmp(d, "DoubleUp")) return '2';
  if (!strcmp(d, "DoubleDown")) return '4';
  return 0;
}

int trendWidth(const char *d) {
  bool dbl;
  char g = trendGlyph(d, dbl);
  if (!g) return 0;
  if (dbl) return DOUBLE_GAP + arrowSmall.glyphs[g - arrowSmall.first].w;
  return arrowBig.glyphs[g - arrowBig.first].w;
}

void drawTrend(int x, int cy, const char *d, uint16_t c) {
  bool dbl;
  char g = trendGlyph(d, dbl);
  if (!g) return;
  int cx = x + trendWidth(d) / 2;
  if (dbl) {
    aaIcon(arrowSmall, g, cx - DOUBLE_GAP / 2, cy, c);
    aaIcon(arrowSmall, g, cx + DOUBLE_GAP / 2, cy, c);
  } else {
    aaIcon(arrowBig, g, cx, cy, c);
  }
}

// ======================================================================
//  Screen parts
// ======================================================================
void drawTopBar(time_t now, const char *middle, uint16_t middleColor, bool wifiOk) {
  char clock[8] = "--:--";
  if (now) { struct tm tm; localtime_r(&now, &tm); strftime(clock, sizeof clock, "%H:%M", &tm); }
  const int base = 28;
  aaText(fontSmall, 14, base, clock, C_DIM, 0);
  aaTextCentered(fontSmall, 240, base, middle, middleColor);

  // Snooze indicator, left of the Wi-Fi icon
  if (snoozed()) {
    char z[16];
    snprintf(z, sizeof z, "zz %dm", snoozeMinutesLeft());
    aaText(fontTiny, 432 - aaWidth(fontTiny, z, 0), 25, z, C_WARN, 0);
  }

  // Wi-Fi bars, or a red X when disconnected
  const int bx = 444, by = 26;
  if (wifiOk) {
    for (int i = 0; i < 3; i++) gfx->fillRect(bx + i * 9, by - 6 - i * 5, 6, 6 + i * 5, C_DIM);
  } else {
    for (int o = -1; o <= 1; o++) {
      gfx->drawLine(bx + o, by - 16, bx + 22 + o, by, C_URG);
      gfx->drawLine(bx + o, by, bx + 22 + o, by - 16, C_URG);
    }
  }
}

const int GX = 12, GY = 210, GW = 410, GH = 78;   // graph area
const float G_MIN = 2.0f, G_MAX = 16.0f;

int graphY(float v) {
  v = constrain(v, G_MIN, G_MAX);
  return GY + GH - (int)((v - G_MIN) / (G_MAX - G_MIN) * GH);
}
int graphX(int bucket) { return GX + 4 + bucket * (GW - 8) / 35; }

void drawGraph(time_t ref, bool stale) {
  int yHigh = graphY(thHigh), yLow = graphY(thLow);
  gfx->fillRect(GX, yHigh, GW, yLow - yHigh, C_BAND);
  for (int x = GX; x < GX + GW; x += 8) {
    gfx->drawFastHLine(x, yHigh, 4, C_DASH);
    gfx->drawFastHLine(x, yLow, 4, C_DASH);
  }
  char buf[8];
  snprintf(buf, sizeof buf, "%.1f", thHigh); aaText(fontTiny, GX + GW + 8, yHigh + 6, buf, C_AXIS, 0);
  snprintf(buf, sizeof buf, "%.1f", thLow);  aaText(fontTiny, GX + GW + 8, yLow + 6, buf, C_AXIS, 0);

  // 36 dots across the graph, newest reading in each slot.
  // 3 h = one per 5 min, 6 h = one per 10 min, 12 h = one per 20 min.
  const long span = graphHours * 3600L, slot = span / 36;
  float bucket[36];
  for (int i = 0; i < 36; i++) bucket[i] = NAN;
  for (int i = 0; i < nReadings; i++) {
    long age = (long)(ref - readings[i].t);
    if (age < 0) age = 0;
    if (age >= span) break;             // readings are newest first
    int b = 35 - age / slot;
    if (isnan(bucket[b])) bucket[b] = readings[i].mmol;
  }
  for (int i = 0; i < 36; i++) {
    if (isnan(bucket[i])) continue;
    gfx->fillCircle(graphX(i), graphY(bucket[i]), 3, stale ? C_GREY : colorFor(bucket[i]));
  }

  const int ly = GY + GH + 20;
  for (int i = 0; i < 3; i++) {                     // e.g. -3h -2h -1h  or  -12h -8h -4h
    char lbl[8];
    snprintf(lbl, sizeof lbl, "-%dh", graphHours * (3 - i) / 3);
    aaText(fontTiny, graphX(i * 12), ly, lbl, C_AXIS, 0);
  }
  aaText(fontTiny, GX + GW - aaWidth(fontTiny, "now", 0), ly, "now", C_AXIS, 0);
}

void drawScreen() {
  gfx->fillScreen(C_BLACK);
  time_t now = nowUtc();
  bool wifiOk = WiFi.status() == WL_CONNECTED;

  if (!haveData) {
    drawTopBar(now, "", C_SUB, wifiOk);
    aaTextCentered(fontSmall, 240, 165, wifiOk ? "Loading Nightscout..." : "Connecting to Wi-Fi...", C_SUB);
    if (lastError.length()) aaTextCentered(fontTiny, 240, 205, lastError.c_str(), C_WARN);
    gfx->flush();
    return;
  }

  const Reading &r = readings[0];
  long ageMin = now ? (long)(now - r.t) / 60 : -1;
  if (ageMin < 0 && now) ageMin = 0;
  bool stale = ageMin >= STALE_MINUTES;

  // Top bar: change + age, or a stale warning
  char ago[20], middle[40];
  if (ageMin < 0) strcpy(ago, "");
  else if (ageMin == 0) strcpy(ago, "just now");
  else snprintf(ago, sizeof ago, "%ld min ago", ageMin);
  float d;
  if (stale) snprintf(middle, sizeof middle, "No data   %s", ago);
  else if (getDelta(d)) snprintf(middle, sizeof middle, "%+.1f   %s", d, ago);
  else snprintf(middle, sizeof middle, "%s", ago);
  drawTopBar(now, middle, stale ? C_WARN : C_SUB, wifiOk);

  // Big number + trend arrow, centred together
  char val[8];
  snprintf(val, sizeof val, "%.1f", r.mmol);
  uint16_t c = stale ? C_GREY : colorFor(r.mmol);
  const int TRACK = -6;                 // tighter letter spacing, like the mockup
  const int numBase = 190;              // baseline of the big number
  const AAGlyph &g8 = fontBig.glyphs['8' - fontBig.first];
  const int numMid = numBase + g8.yOff + g8.h / 2;   // vertical centre of the digits
  int numW = aaWidth(fontBig, val, TRACK);
  int arrW = trendWidth(trend);
  int total = numW + (arrW ? 24 + arrW : 0);
  int x0 = (480 - total) / 2;
  // Flashing: hide the number and arrow every other half second
  bool hidden = shouldFlash() && ((millis() / 500) % 2 == 1);
  if (!hidden) {
    aaText(fontBig, x0, numBase, val, c, TRACK);
    if (arrW) drawTrend(x0 + numW + 24, numMid, trend, c);
  }
  if (stale) gfx->fillRect(x0 - 8, numMid - 4, total + 16, 8, C_DIM);   // strike through

  drawGraph(now ? now : r.t, stale);
  gfx->flush();
}

// ======================================================================
void setup() {
  Serial.begin(115200);
  delay(500);
  Serial.println("Nightscout display starting");

  if (!gfx->begin()) {
    Serial.println("gfx->begin() failed! Check Tools > PSRAM > OPI PSRAM.");
    while (true) delay(1000);
  }
  ledcAttach(TFT_BL, 5000, 8);          // backlight as PWM so night mode can dim it
  updateBacklight();
  drawScreen();

  touchBegin();
  beeperBegin();
  if (STARTUP_BEEP) playChirp(ALARM_VOLUME);

  WiFi.mode(WIFI_STA);
  WiFi.setAutoReconnect(true);          // short drops: the ESP32 rejoins the same network itself
  connectWifi();
}

bool tryWifi(int k, uint32_t timeoutMs) {
  Serial.printf("Wi-Fi: trying \"%s\"...\n", WIFI_NAMES[k]);
  lastError = String("Trying ") + WIFI_NAMES[k] + "...";
  drawScreen();
  WiFi.disconnect();
  delay(100);
  WiFi.begin(WIFI_NAMES[k], WIFI_PASSES[k]);
  uint32_t t = millis();
  while (WiFi.status() != WL_CONNECTED && millis() - t < timeoutMs) delay(100);
  if (WiFi.status() == WL_CONNECTED) {
    Serial.printf("Wi-Fi connected to \"%s\", IP %s, signal %d dBm\n",
                  WIFI_NAMES[k], WiFi.localIP().toString().c_str(), WiFi.RSSI());
    lastError = "";
    return true;
  }
  Serial.printf("Wi-Fi: \"%s\" failed (status %d)\n", WIFI_NAMES[k], (int)WiFi.status());
  return false;
}

// 1) Scan and join the strongest saved network that's in range.
// 2) If none was seen (e.g. hidden network) or joining failed, try each saved network by name.
void connectWifi() {
  Serial.println("Wi-Fi: scanning...");
  lastError = "Scanning for Wi-Fi...";
  drawScreen();
  int n = WiFi.scanNetworks();
  int best = -1, bestRssi = -1000;
  for (int i = 0; i < n; i++) {
    Serial.printf("  seen: \"%s\" %d dBm\n", WiFi.SSID(i).c_str(), WiFi.RSSI(i));
    for (int k = 0; k < 3; k++) {
      if (strlen(WIFI_NAMES[k]) && WiFi.SSID(i) == WIFI_NAMES[k] && WiFi.RSSI(i) > bestRssi) {
        best = k;
        bestRssi = WiFi.RSSI(i);
      }
    }
  }
  WiFi.scanDelete();
  if (best >= 0 && tryWifi(best, 15000)) return;
  for (int k = 0; k < 3; k++) {
    if (k == best || !strlen(WIFI_NAMES[k])) continue;
    if (tryWifi(k, 10000)) return;
  }
  lastError = "Can't connect to your Wi-Fi - retrying";
  Serial.println("Wi-Fi: no saved network worked; will retry");
}

// Reconnect after moving building / router restart.
void handleWifi() {
  bool connected = WiFi.status() == WL_CONNECTED;
  if (!connected && wasConnected) {
    Serial.println("Wi-Fi lost");
    lostSinceMs = millis();
  }
  wasConnected = connected;
  if (connected) { lostSinceMs = 0; return; }
  if (lostSinceMs == 0) lostSinceMs = millis();
  // Give the automatic reconnect 20 s, then search all saved networks; repeat every 20 s.
  if (millis() - lostSinceMs >= 20000) {
    connectWifi();
    lostSinceMs = millis();
    if (lostSinceMs == 0) lostSinceMs = 1;
  }
}

// Tap: snooze the alarm if it's sounding, otherwise switch graph range 3h -> 6h -> 12h.
void handleTouch() {
  bool t = touchPressed();
  if (t && !lastTouch) {
    if (lowAlarm() && !snoozed()) {
      snoozeUntilMs = millis() + SNOOZE_MINUTES * 60000UL;
      if (snoozeUntilMs == 0) snoozeUntilMs = 1;
      lastAlarmMs = 0;
      Serial.println("Alarm snoozed");
    } else {
      int idx = 0;
      for (int i = 0; i < 3; i++) if (GRAPH_RANGES[i] == graphHours) idx = i;
      graphHours = GRAPH_RANGES[(idx + 1) % 3];
      Serial.printf("Graph: %d hours\n", graphHours);
    }
    drawScreen();
    lastDrawMs = millis();
  }
  lastTouch = t;
}

void handleAlarm() {
  if (!lowAlarm()) {                    // back above urgent low (or no fresh data): reset
    snoozeUntilMs = 0;
    lastAlarmMs = 0;
    return;
  }
  if (snoozed()) return;
  snoozeUntilMs = 0;                    // snooze has run out
  if (lastAlarmMs == 0 || millis() - lastAlarmMs >= ALARM_REPEAT_S * 1000UL) {
    updateBacklight();                  // full brightness before beeping
    playAlarm(ALARM_VOLUME);
    lastAlarmMs = millis();
    if (lastAlarmMs == 0) lastAlarmMs = 1;
  }
}

void loop() {
  handleTouch();
  handleAlarm();
  updateBacklight();

  // Flashing number: redraw whenever the on/off phase changes
  if (shouldFlash()) {
    int phase = (millis() / 500) % 2;
    if (phase != lastFlashPhase) {
      drawScreen();
      lastDrawMs = millis();
      lastFlashPhase = phase;
    }
  } else {
    lastFlashPhase = -1;
  }

  handleWifi();

  uint32_t ms = millis();
  if (WiFi.status() == WL_CONNECTED) {
    if (millis() - lastFullFetchMs >= 3600000UL) needFullFetch = true;   // full refresh hourly
    if (!ntpStarted) {
      configTzTime(TZ_INFO, "pool.ntp.org", "time.google.com");
      ntpStarted = true;
    }
    if ((int32_t)(ms - nextStatusMs) >= 0) {
      // Thresholds: refresh hourly; retry after a minute if it failed.
      nextStatusMs = ms + (fetchStatus() ? 3600000UL : 60000UL);
    }
    if (!fetchedOnce || ms - lastFetchMs >= FETCH_INTERVAL_S * 1000UL) {
      if (!fetchEntries()) Serial.println("Fetch failed: " + lastError);
      fetchedOnce = true;
      lastFetchMs = millis();
      drawScreen();
      lastDrawMs = millis();
    }
  }

  // Redraw every few seconds so the clock and "min ago" stay current.
  if (millis() - lastDrawMs >= 5000) {
    drawScreen();
    lastDrawMs = millis();
  }
  delay(50);
}
